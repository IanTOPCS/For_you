LENGTH EQU 8;
MAIN:
	MOV DPTR, #SegmentCode;
	MOV R0, #0;
LOOP:
	MOV A, R0;
	MOVC A, @A+DPTR;
	MOV P1, A;
	JMP NEXT;

NEXT:
	JNB P2.0, R0INC;
	JMP R0DEC;
	
R0INC:
	INC R0;
	CJNE R0, #LENGTH, LOOP;
	MOV R0, #0;
	JMP LOOP;
	
R0DEC:;
	CJNE R0, #0, DEC0;
	MOV R0, #LENGTH;
	DEC R0;
	JMP LOOP;
DEC0:
	DEC R0
	JMP LOOP;
SegmentCode:
	DB 0xC0, 0xF9, 0xA4, 0xB0, 0x99, 0x92, 0x82, 0xD8, 0x80, 0x90, 0x88, 0x83, 0xC6, 0xA1, 0x86, 0x8E
	