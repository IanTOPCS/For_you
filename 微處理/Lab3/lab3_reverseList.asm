		ORG	0H
		JMP	INIT
LENGTH	EQU	40H
ARRAY 	EQU 	41H
		ORG	30H
INIT:
		MOV 40H, #7
		MOV 41H, #'K'
		MOV 42H, #'e'
		MOV 43H, #'i'
		MOV 44H, #'l'
		MOV 45H, #'A'
		MOV 46H, #'5'
		MOV 47H, #'1'

MAIN:
		; GET HOW MANY TIME TO DIV
		MOV B, #0X02
		MOV A, LENGTH
		DIV AB
		; STORE DIV TIME TO R3
		MOV R3, A
		; MOV TO END OF ARRAY
		MOV A, LENGTH
		ADDC A, #ARRAY
		DEC A
		MOV R1, A
		; MOV TO BEGIN OF ARRAY
		MOV R0, #ARRAY
LOOP:
		MOV A, @R1
		MOV R2, A
		MOV A, @R0
		MOV @R1, A
		MOV A, R2
		MOV @R0, A 
		DEC R1
		INC R0
		DEC R3
		CJNE R3, #0X00, LOOP
		JMP $