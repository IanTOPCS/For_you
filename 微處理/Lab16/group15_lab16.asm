ORG 00H
LJMP MAIN;

ORG 000BH
LJMP T0ISR;

ORG 0013H;
LJMP BUTTON;

MAIN:
	MOV SP, #40H
	MOV TMOD, #02H
	MOV TH0, #-30
	MOV R7, #10
	MOV R6, #6
	MOV R5, #6

	MOV R4, #10
	CLR P0.2
	
	SETB TR0
	SETB IT1
	MOV IE, #86H
	
	SJMP $
BUTTON:
	JNB P0.6, GET6
	JNB P0.5, GET5
	JNB P0.4, GET4
	RETI
GET4:
	DJNZ R6, KYS4 
	INC R6
	RETI
KYS4:
	INC R5
	RETI
GET5:
	CPL TR0
	RETI
GET6:
	DJNZ R5, KYS6
	INC R5
	RETI
KYS6:
	INC R6;
	RETI
LABLERETI:
	RETI
T0ISR:
	DJNZ R4, LABLERETI
	CALL FLASH_YELLOW
	MOV A, #5
	ADD A, R6
	MOV R4, A
	DEC R4
	MOV R3, AR4
	RETI
FLASH_YELLOW:
	CPL P1.1;
	RET;